Commit message: TCP as EE name

File: ModularBot_1DOF/urdf/ModularBot.urdf (robot description, URDF)
Before this commit: robot ModularBot_1DOF, 9 links, 8 joints
Links:
- removed link TCP_gripper_A
- added link TCP
Joints:
- joint fixed_TCP_gripper_A: child TCP_gripper_A -> TCP
